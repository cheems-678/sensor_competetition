# Keil uVision project modules.uvprojx, settings and files
target Target (6180000::V6.18::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: modules
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: .\;.\stdlib\STM32F10x_StdPeriph_Driver\inc;.\stdlib\CMSIS\CM3\CoreSupport;.\stdlib\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\modules\sensor;.\modules\tomography;.\modules\lora;.\modules\fan;.\modules\servo;.\modules\buzzer;.\modules\ws2812b;.\modules\bh1750;.\modules\dht11
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StandardLib
    ./stdlib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ./stdlib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ./stdlib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group App
    ./: main.c stm32f10x_it.c
    ./modules/sensor/: sensor.c
    ./modules/tomography/: tomography.c
    ./modules/lora/: lora.c
    ./modules/fan/: fan.c
    ./modules/servo/: servo.c
    ./modules/buzzer/: buzzer.c
    ./modules/ws2812b/: ws2812b.c
    ./modules/bh1750/: bh1750.c
    ./modules/dht11/: dht11.c
